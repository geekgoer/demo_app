YAML_COMPILER_FLAGS_append = " -DENABLE_PM"
YAML_COMPILER_FLAGS_append = " -DENABLE_IOCTL"